SRC_URI += "file://wdmp-c.patch"
FILESEXTRAPATHS_prepend:= "${THISDIR}/files:"
