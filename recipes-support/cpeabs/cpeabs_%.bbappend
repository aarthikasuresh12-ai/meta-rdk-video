SUMMARY = "cpeabs- Handle patches"
HOMEPAGE = "https://github.com/xmidt-org/cpeabs"

FILESEXTRAPATHS_prepend := "${THISDIR}/"
SRC_URI += "file://cpeabs_video-changes.patch"
