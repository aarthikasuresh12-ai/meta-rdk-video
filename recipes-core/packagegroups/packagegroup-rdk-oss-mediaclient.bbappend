RDEPENDS_packagegroup-rdk-oss-mediaclient_append = "\
    avahi-daemon \
    "
