SYSTEMD_AUTO_ENABLE_${PN}-daemon = "disable"
